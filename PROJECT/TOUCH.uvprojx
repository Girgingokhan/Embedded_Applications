# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\SPI;..\HARDWARE\RTC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c GUI.c stm32f4xx_it.c system_stm32f4xx.c pic.h
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/24CXX/: 24cxx.c 24cxx.h
    ../HARDWARE/IIC/: myiic.c myiic.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/TOUCH/: touch.c touch.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_tim.c
